# Keil uVision project watertower.uvprojx, settings and files
target STM32F103RE Flash (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: watertower
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STDOUT_CR_LF=1,STDERR_CR_LF=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: blinky.cpp main.cpp stdio_UART.cpp ultrasonicranging.cpp si4432.cpp multipointcom.cpp
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, Compiler:I/O:STDERR 1.0.0, Compiler:I/O:STDIN 1.0.0, Compiler:I/O:STDOUT 1.0.0, Device:DMA 1.01.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Drivers:SPI 1.03.0, Drivers:UART 1.01.0
